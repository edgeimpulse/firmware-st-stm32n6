<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\ADC_FixedTriggerLatency_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
