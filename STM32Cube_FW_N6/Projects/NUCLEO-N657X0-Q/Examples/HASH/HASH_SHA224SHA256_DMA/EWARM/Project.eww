<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\HASH_SHA224SHA256_DMA_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
