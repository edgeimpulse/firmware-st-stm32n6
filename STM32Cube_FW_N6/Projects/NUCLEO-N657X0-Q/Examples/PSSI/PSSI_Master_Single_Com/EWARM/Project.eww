<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\PSSI_Master_Single_Com_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
