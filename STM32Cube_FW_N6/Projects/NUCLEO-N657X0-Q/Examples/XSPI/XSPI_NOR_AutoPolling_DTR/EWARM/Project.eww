<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\XSPI_NOR_AutoPolling_DTR_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
