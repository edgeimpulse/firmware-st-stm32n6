<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\UART_ReceptionToIdle_CircularDMA_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
