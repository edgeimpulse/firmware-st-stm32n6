<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\PKA_ECDSA_Verify_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
