<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\FLEXMEM_Configurations_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
