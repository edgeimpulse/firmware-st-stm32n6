# IAR project CORTEX_InterruptSwitch_TrustZone_AppliNonSecure_NS.ewp, settings and files
configuration CORTEX_InterruptSwitch_TrustZone_AppliNonSecure_NS (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32N657xx
  ICCARM.CCIncludePath2: ../../AppliNonSecure/Inc; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ../../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: CORTEX_InterruptSwitch_TrustZone_AppliNonSecure_NS.out
  ILINK.IlinkKeepSymbols: fsbl_bin
  ILINK.IlinkIcfFile: stm32n657xx_fsbl_ns.icf
  ILINK.IlinkExtraOptions: --no-range_reservations
  ILINK.IlinkAdditionalLibs: ..\FSBL\CORTEX_InterruptSwitch_TrustZone_FSBL\Exe\CORTEX_InterruptSwitch_TrustZone_FSBL_import_lib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32n657xx.s
  group Application/User/AppliNonSecure
    ../../AppliNonSecure/Src/: main.c stm32n6xx_hal_msp.c stm32n6xx_it.c
  group Doc
    ../../: Readme.md
  group Drivers/CMSIS
    ../../AppliNonSecure/Src/: system_stm32n6xx_ns.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c
