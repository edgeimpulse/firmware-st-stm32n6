# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-N657X0-Q_Template (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.0.1.2
  cpu: IRAM(0x00000000,0x00040000) IRAM2(0x20000000,0x00040000) XRAM(0x24000000,0x3E0000) XRAM2(0x25000000,0x01000000) XRAM3(0x28000000,0x00008000) CPUTYPE("Cortex-M55") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Project
  AfterMake: fromelf.exe --bin Objects\Project.axf  --output Objects\Project.bin
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32N657xx,USE_HAL_DRIVER, DATATYPE
  c include: ../FSBL/Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32N6xx_Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x34180400 size 0x3fc00
  memory RVCT6: RAM 0x24000000 size 0x3e0000
  memory RVCT7: RAM 0x25000000 size 0x1000000
  memory RVCT8: RAM 0x28000000 size 0x8000
  memory RVCT9: RAM 0x341c0000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\stm32n657xx_axisram2_fsbl.sct
  link misc: --diag_suppress L6848W
  group Doc
    ../: README.md
  group Drivers/BSP/STM32N6xx_Nucleo
    ../../../../../Drivers/BSP/STM32N6xx_Nucleo/: stm32n6xx_nucleo.c
  group Drivers/STM32N6xx_HAL_Drivers
    ../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c
  group Drivers/CMSIS
    ../FSBL/Src/: system_stm32n6xx_fsbl.c
  group Example/MDK-ARM
    ./: startup_stm32n657xx_fsbl.c
  group Example
    ../FSBL/Src/: main.c stm32n6xx_it.c
