# IAR project Project_ns.ewp, settings and files
configuration STM32N6xx_Nucleo_NonSecure (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; __TERMINAL_IO__; USE_FULL_ASSERT; STM32N6XX_SI_CUT1_1
  ICCARM.CCIncludePath2: ..\..\AppliNonSecure\Inc; ..\..\Secure_nsclib; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32N6xx_Nucleo
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project_ns.bin
  ILINK.IlinkOutputFile: STM32N657xx.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram_ns.icf
  ILINK.IlinkAdditionalLibs: ..\AppliSecure\STM32N6xx_Nucleo_Secure\Exe\Project_import_lib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32N6xx_Nucleo/: stm32n6xx_nucleo.c
  group Drivers/CMSIS
    ./: startup_stm32n657xx_ns.s
    ../../AppliNonSecure/Src/: system_stm32n6xx_ns.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c
  group Example
    ../../AppliNonSecure/Src/: main.c stm32n6xx_it.c
