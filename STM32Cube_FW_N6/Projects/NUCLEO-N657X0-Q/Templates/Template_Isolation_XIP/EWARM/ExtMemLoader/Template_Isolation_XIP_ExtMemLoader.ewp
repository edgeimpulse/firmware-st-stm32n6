# IAR project Template_Isolation_XIP_ExtMemLoader.ewp, settings and files
configuration Template_Isolation_XIP_ExtMemLoader (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; STM32_EXTMEMLOADER_EWARMTARGET_NA; STM32_EXTMEMLOADER_STM32CUBETARGET
  ICCARM.CCIncludePath2: ../../ExtMemLoader/Inc; ../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/boot; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sdcard; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/user; ..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Loader; ..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Loader\EWARM; ..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Loader\STM32Cube; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include\Templates; ..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Loader\core
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template_Isolation_XIP_ExtMemLoader.srec
  ILINK.IlinkOutputFile: Template_Isolation_XIP_ExtMemLoader.out
  ILINK.IlinkIcfFile: stm32n6xx_extmemloader_stm32cube.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User/ExtMemLoader
    ../../ExtMemLoader/Src/: extmem_manager.c extmemloader_init.c stm32n6xx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../ExtMemLoader/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_xspi.c
  group Middlewares/STM32_ExtMem_Loader
    ../../../../../../Middlewares/ST/STM32_ExtMem_Loader/EWARM/: flash_loader.c flash_loader_asm.s stm32_flash_wrapper.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Loader/MDK-ARM/: FlashDev.c FlashPrg.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Loader/core/: memory_wrapper.c systick_management.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Loader/STM32Cube/: stm32_device_info.c stm32_loader_api.c
  group Middlewares/STM32_ExtMem_Manager
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/boot/: stm32_boot_xip.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram/: stm32_psram_driver.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_xspi.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
