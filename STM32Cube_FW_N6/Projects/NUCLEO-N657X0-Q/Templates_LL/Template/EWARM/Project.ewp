# IAR project Project.ewp, settings and files
configuration NUCLEO-N657X0-Q_Templates_LL (ARM, debug)
  General.OGChipSelectEditMenu: STM32N6570-NUCLEO ST STM32N6570-NUCLEO
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\FSBL\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram2_fsbl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ./: startup_stm32n657xx_fsbl.s
    ../FSBL/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_ll_adc.c stm32n6xx_ll_crc.c stm32n6xx_ll_dma.c stm32n6xx_ll_dma2d.c stm32n6xx_ll_exti.c stm32n6xx_ll_gpio.c stm32n6xx_ll_i2c.c stm32n6xx_ll_i3c.c stm32n6xx_ll_lptim.c stm32n6xx_ll_lpuart.c stm32n6xx_ll_pka.c stm32n6xx_ll_pwr.c stm32n6xx_ll_rcc.c stm32n6xx_ll_rng.c stm32n6xx_ll_rtc.c stm32n6xx_ll_spi.c stm32n6xx_ll_tim.c stm32n6xx_ll_ucpd.c stm32n6xx_ll_usart.c stm32n6xx_ll_utils.c stm32n6xx_ll_venc.c
  group Example
    ../FSBL/Src/: main.c stm32n6xx_it.c
