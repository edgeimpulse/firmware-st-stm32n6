<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\FMC_NAND_Load_And_Run_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
