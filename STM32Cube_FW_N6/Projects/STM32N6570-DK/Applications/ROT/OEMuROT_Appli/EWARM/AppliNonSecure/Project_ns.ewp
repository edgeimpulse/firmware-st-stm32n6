# IAR project Project_ns.ewp, settings and files
configuration STM32N6570-DK_OEMuROT_Appli_NonSecure (ARM, debug)
  General.OGChipSelectEditMenu: STM32N6570-DK ST STM32N6570-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; __TERMINAL_IO__; USE_FULL_ASSERT; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\..\AppliNonSecure\Inc; ..\..\Secure_nsclib; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\..\..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM32N6570-DK; ..\..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Manager; ..\..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Manager\nor_sfdp; ..\..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Manager\sal; ..\..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\ext\driver
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../Binary/rot_ns_app.bin
  ILINK.IlinkOutputFile: STM32N657xx.out
  ILINK.IlinkIcfFile: stm32n657xx_ROMxspi2_axisram_ns.icf
  ILINK.IlinkAdditionalLibs: ..\AppliSecure\STM32N6570-DK_OEMuROT_Appli_Secure\Exe\Project_import_lib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c
  group Drivers/CMSIS
    ./: startup_stm32n657xx_ns.s
    ../../AppliNonSecure/Src/: system_stm32n6xx_ns.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_crc.c stm32n6xx_hal_crc_ex.c stm32n6xx_hal_dma.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_hal_xspi.c
  group Middlewares/STM32_ExtMem_Manager
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
  group Middlewares/STM32_ExtMem_Manager/SAL
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_xspi.c
  group Middlewares/STM32_ExtMem_Manager/SFDP
    ../../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
  group Example
    ../../AppliNonSecure/Src/: com.c common.c fw_update_app.c low_level_device.c low_level_ext_flash.c low_level_extmem_device.c main.c stm32n6xx_it.c ymodem.c
