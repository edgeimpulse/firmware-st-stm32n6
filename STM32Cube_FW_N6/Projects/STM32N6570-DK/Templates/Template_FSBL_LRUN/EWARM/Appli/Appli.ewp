# IAR project Appli.ewp, settings and files
configuration STM32N6570-DK_Template_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32N6570-DK ST STM32N6570-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ..\..\Appli\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32N6570-DK
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32n657xx_LRUN.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32N6570-DK_Appli_Debug (ARM, debug)
  as the first configuration, except:
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c
  group Drivers/CMSIS
    ./: startup_stm32n657xx.s
    ../FSBL/: startup_stm32n657xx_fsbl.s
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
    ../../Appli/Src/: system_stm32n6xx_s.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c
  group Example
    ../../Appli/Src/: main.c stm32n6xx_hal_msp.c stm32n6xx_it.c
