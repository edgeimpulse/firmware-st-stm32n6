<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>Project.uvmpw</WorkspaceName>

  <project>
    <PathAndName>.\FSBL\FSBL.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\AppliSecure\Project_s.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\AppliNonSecure\Project_ns.uvprojx</PathAndName>
  </project>

</ProjectWorkspace>
