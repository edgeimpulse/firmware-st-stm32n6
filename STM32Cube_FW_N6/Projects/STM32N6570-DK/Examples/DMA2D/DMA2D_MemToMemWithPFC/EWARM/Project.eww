<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\DMA2D_MemoryToMemoryPFC_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
