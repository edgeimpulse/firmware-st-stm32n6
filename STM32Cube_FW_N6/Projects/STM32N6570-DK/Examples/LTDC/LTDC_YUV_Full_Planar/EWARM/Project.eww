<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\LTDC_YUV_Full_Planar_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
