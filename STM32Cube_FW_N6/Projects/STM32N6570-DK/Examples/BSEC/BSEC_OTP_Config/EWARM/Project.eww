<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\BSEC_OTP_Config_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
