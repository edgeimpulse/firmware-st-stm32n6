<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\App_NonSecure\Project_ns.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\App_Secure\Project_s.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\FSBL\FSBL.ewp</path>
    </project>
    <batchBuild />
</workspace>
