# IAR project stm32n6_ai_rtos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32N6570-DK ST STM32N6570-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; VECT_TAB_SRAM; STM32N6570_DK_REV=STM32N6570_DK_C01; TX_MAX_PARALLEL_NETWORKS=1; LL_ATON_DUMP_DEBUG_API; LL_ATON_PLATFORM=LL_ATON_PLAT_STM32N6; LL_ATON_OSAL=LL_ATON_OSAL_THREADX; LL_ATON_RT_MODE=LL_ATON_RT_ASYNC; LL_ATON_SW_FALLBACK; USE_IMX335_SENSOR; TX_SINGLE_MODE_SECURE; FEAT_THREADX; TX_INCLUDE_USER_DEFINE_FILE; TX_EXECUTION_PROFILE_ENABLE
  ICCARM.CCIncludePath2: ..\Inc; ..\STM32Cube_FW_N6/Drivers/STM32N6xx_HAL_Driver/Inc; ..\STM32Cube_FW_N6/Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ..\STM32Cube_FW_N6/Drivers/CMSIS/Device/ST/STM32N6xx/Include; ..\STM32Cube_FW_N6/Drivers/CMSIS/Include; ..\STM32Cube_FW_N6/Drivers/CMSIS/DSP/Include; ..\STM32Cube_FW_N6/Drivers/BSP/Components/Common; ..\STM32Cube_FW_N6/Drivers/BSP/STM32N6570-DK; ..\STM32Cube_FW_N6/Utilities/lcd; ..\STM32Cube_FW_N6/Drivers/BSP/Components/aps256xx; ..\Lib/AI_Runtime/Inc; ..\Lib/AI_Runtime/ll_aton; ..\Lib/Objdetect_pp/lib_objdetect_pp/Inc; ..\Lib/Camera_Middleware; ..\Lib/Camera_Middleware/sensors; ..\Lib/Camera_Middleware/sensors/imx335; ..\Lib/Camera_Middleware/sensors/ov5640; ..\Lib/Camera_Middleware/sensors/vd55g1; ..\Lib/Camera_Middleware/sensors/vd6g; ..\Lib/Camera_Middleware/sensors/vd1941; ..\Lib/Camera_Middleware/ISP_Library/isp/Inc; ..\Lib/Camera_Middleware/ISP_Library/evision/Inc; ..\STM32Cube_FW_N6/Middlewares/ST/Inc; ..\STM32Cube_FW_N6/Middlewares/ST/threadx/common/inc; ..\STM32Cube_FW_N6/Middlewares/ST/threadx/ports/cortex_m55/gnu/inc; ..\STM32Cube_FW_N6/Middlewares/ST/threadx/utility/execution_profile_kit
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: STM32N6_AI_RTOS.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram.icf
  ILINK.IlinkAdditionalLibs: ..\Lib/AI_Runtime/Lib/NetworkRuntime1000_CM55_IAR.a; ..\Lib/Camera_Middleware/ISP_Library/evision/Lib/libn6-evision_IAR.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM/Src
    ../EWARM/Src/: console.c startup_stm32n657xx.s tx_initialize_low_level.s
  group Lib/AI_Runtime/ll_aton
    ../Lib/AI_Runtime/ll_aton/: ll_aton.c ll_aton_osal_threadx.c ll_aton_debug.c ll_aton_lib.c ll_aton_lib_sw_operators.c ll_aton_rt_main.c ll_aton_runtime.c ll_aton_util.c ll_sw_float.c ll_sw_integer.c
  group Lib/Camera_Middleware
    ../Lib/Camera_Middleware/: cmw_camera.c cmw_utils.c
  group Lib/Camera_Middleware/ISP_Library/isp/Src
    ../Lib/Camera_Middleware/ISP_Library/isp/Src/: isp_algo.c isp_cmd_parser.c isp_core.c isp_services.c isp_tool_com.c
  group Lib/Camera_Middleware/sensors
    ../Lib/Camera_Middleware/sensors/: cmw_vd55g1.c cmw_ov5640.c cmw_imx335.c cmw_vd66gy.c cmw_vd1941.c
  group Lib/Camera_Middleware/sensors/imx335
    ../Lib/Camera_Middleware/sensors/imx335/: imx335.c imx335_reg.c
  group Lib/Camera_Middleware/sensors/ov5640
    ../Lib/Camera_Middleware/sensors/ov5640/: ov5640_reg.c ov5640.c
  group Lib/Camera_Middleware/sensors/vd1941
    ../Lib/Camera_Middleware/sensors/vd1941/: vdx941.c
  group Lib/Camera_Middleware/sensors/vd55g1
    ../Lib/Camera_Middleware/sensors/vd55g1/: vd55g1.c
  group Lib/Camera_Middleware/sensors/vd6g
    ../Lib/Camera_Middleware/sensors/vd6g/: vd6g.c
  group Lib/Objdetect_pp/lib_objdetect_pp/Src
    ../Lib/Objdetect_pp/lib_objdetect_pp/Src/: objdetect_pp.c objdetect_pp_yolov2.c objdetect_pp_yolov5.c objdetect_pp_yolov8.c
  group Model
    ../Model/: network.c
  group STM32Cube_FW_N6/Drivers/BSP/Components/aps256xx
    ../STM32Cube_FW_N6/Drivers/BSP/Components/aps256xx/: aps256xx.c
  group STM32Cube_FW_N6/Drivers/BSP/Components/mx66uw1g45g
    ../STM32Cube_FW_N6/Drivers/BSP/Components/mx66uw1g45g/: mx66uw1g45g.c
  group STM32Cube_FW_N6/Drivers/BSP/STM32N6570-DK
    ../STM32Cube_FW_N6/Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery_bus.c stm32n6570_discovery_lcd.c stm32n6570_discovery_xspi.c
  group STM32Cube_FW_N6/Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates
    ../STM32Cube_FW_N6/Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/: system_stm32n6xx_fsbl.c
  group STM32Cube_FW_N6/Drivers/STM32N6xx_HAL_Driver/Src
    ../STM32Cube_FW_N6/Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dcmipp.c stm32n6xx_hal_dma2d.c stm32n6xx_hal_gpio.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_ltdc.c stm32n6xx_hal_ltdc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_ramcfg.c stm32n6xx_hal_cacheaxi.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_xspi.c stm32n6xx_hal_bsec.c stm32n6xx_hal_uart.c
  group STM32Cube_FW_N6/Middlewares/ST/threadx/common/src
    ../STM32Cube_FW_N6/Middlewares/ST/threadx/common/src/: tx_byte_allocate.c tx_mutex_initialize.c tx_thread_wait_abort.c txe_timer_deactivate.c txe_thread_priority_change.c tx_initialize_high_level.c tx_mutex_info_get.c tx_trace_buffer_full_notify.c tx_event_flags_performance_system_info_get.c txe_queue_delete.c txe_block_pool_create.c txe_semaphore_put_notify.c txe_thread_delete.c tx_block_release.c txe_semaphore_get.c txe_mutex_delete.c tx_queue_front_send.c tx_thread_entry_exit_notify.c txe_byte_allocate.c tx_queue_initialize.c tx_byte_pool_create.c tx_semaphore_ceiling_put.c txe_queue_info_get.c tx_event_flags_set_notify.c tx_thread_stack_error_notify.c txe_thread_info_get.c tx_thread_relinquish.c tx_event_flags_delete.c tx_trace_enable.c tx_queue_performance_info_get.c tx_timer_system_deactivate.c tx_thread_resume.c tx_thread_performance_info_get.c tx_event_flags_initialize.c txe_queue_flush.c txe_mutex_info_get.c tx_thread_stack_analyze.c tx_block_pool_performance_system_info_get.c tx_mutex_performance_info_get.c tx_byte_pool_cleanup.c tx_event_flags_info_get.c tx_time_set.c tx_trace_object_register.c tx_block_pool_delete.c tx_trace_event_unfilter.c tx_mutex_get.c tx_trace_isr_exit_insert.c txe_byte_pool_create.c tx_queue_receive.c tx_block_pool_prioritize.c tx_thread_suspend.c tx_byte_release.c txe_queue_prioritize.c tx_thread_info_get.c txe_event_flags_set_notify.c txe_event_flags_delete.c tx_trace_user_event_insert.c tx_mutex_put.c tx_trace_initialize.c tx_semaphore_create.c tx_timer_performance_system_info_get.c tx_thread_sleep.c txe_event_flags_info_get.c tx_thread_reset.c txe_mutex_get.c tx_block_pool_cleanup.c tx_event_flags_performance_info_get.c txe_thread_preemption_change.c tx_semaphore_cleanup.c txe_queue_receive.c txe_block_pool_prioritize.c txe_thread_suspend.c txe_byte_release.c tx_initialize_kernel_enter.c tx_timer_delete.c tx_timer_initialize.c tx_event_flags_get.c txe_semaphore_create.c tx_queue_flush.c tx_thread_time_slice.c tx_byte_pool_prioritize.c tx_mutex_prioritize.c txe_thread_wait_abort.c tx_block_pool_info_get.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_byte_pool_performance_system_info_get.c tx_semaphore_get.c tx_timer_info_get.c tx_timer_deactivate.c tx_timer_system_activate.c tx_trace_disable.c tx_queue_send.c txe_timer_delete.c tx_queue_create.c tx_semaphore_initialize.c txe_event_flags_get.c tx_byte_pool_delete.c txe_thread_entry_exit_notify.c txe_byte_pool_prioritize.c tx_mutex_create.c tx_byte_pool_initialize.c txe_block_pool_info_get.c txe_thread_time_slice_change.c txe_semaphore_put.c tx_block_pool_performance_info_get.c txe_timer_info_get.c txe_queue_create.c tx_semaphore_put.c tx_semaphore_prioritize.c tx_queue_cleanup.c txe_queue_front_send.c tx_timer_performance_info_get.c tx_trace_interrupt_control.c tx_byte_pool_info_get.c tx_semaphore_performance_system_info_get.c tx_misra.c txe_queue_send.c tx_initialize_kernel_setup.c tx_mutex_cleanup.c tx_thread_preemption_change.c tx_thread_system_suspend.c txe_block_release.c tx_block_pool_initialize.c tx_timer_change.c tx_timer_expiration_process.c txe_thread_create.c txe_byte_pool_delete.c txe_semaphore_ceiling_put.c txe_mutex_create.c tx_semaphore_delete.c tx_trace_object_unregister.c txe_thread_reset.c txe_semaphore_prioritize.c tx_event_flags_create.c tx_queue_info_get.c txe_byte_pool_info_get.c tx_byte_pool_performance_info_get.c tx_thread_identify.c tx_timer_activate.c txe_timer_change.c tx_semaphore_info_get.c tx_event_flags_set.c tx_thread_stack_error_handler.c txe_thread_relinquish.c tx_thread_system_resume.c txe_thread_resume.c tx_event_flags_cleanup.c tx_block_allocate.c tx_trace_isr_enter_insert.c tx_queue_prioritize.c tx_timer_thread_entry.c txe_semaphore_delete.c tx_thread_create.c tx_time_get.c txe_block_pool_delete.c tx_queue_performance_system_info_get.c txe_event_flags_create.c tx_queue_send_notify.c tx_thread_performance_system_info_get.c tx_thread_terminate.c tx_mutex_performance_system_info_get.c txe_timer_activate.c txe_semaphore_info_get.c tx_thread_priority_change.c txe_event_flags_set.c tx_thread_shell_entry.c tx_thread_system_preempt_check.c tx_byte_pool_search.c tx_semaphore_performance_info_get.c txe_timer_create.c tx_mutex_priority_change.c txe_block_allocate.c tx_queue_delete.c tx_block_pool_create.c tx_semaphore_put_notify.c tx_thread_delete.c tx_trace_event_filter.c tx_thread_initialize.c tx_timer_create.c tx_mutex_delete.c txe_queue_send_notify.c txe_mutex_put.c txe_mutex_prioritize.c txe_thread_terminate.c
  group STM32Cube_FW_N6/Middlewares/ST/threadx/ports/cortex_m55/iar/src
    ../STM32Cube_FW_N6/Middlewares/ST/threadx/ports/cortex_m55/iar/src/: txe_thread_secure_stack_free.c tx_iar.c txe_thread_secure_stack_allocate.c tx_thread_secure_stack.c tx_timer_interrupt.s tx_thread_context_restore.s tx_thread_schedule.s tx_thread_system_return.s tx_thread_secure_stack_free.s tx_thread_context_save.s tx_thread_secure_stack_initialize.s tx_thread_interrupt_control.s tx_thread_secure_stack_allocate.s tx_thread_stack_build.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s
  group STM32Cube_FW_N6/Middlewares/ST/threadx/utility/execution_profile_kit
    ../STM32Cube_FW_N6/Middlewares/ST/threadx/utility/execution_profile_kit/: tx_execution_profile.c
  group STM32Cube_FW_N6/Utilities/lcd
    ../STM32Cube_FW_N6/Utilities/lcd/: stm32_lcd.c
  group Src
    ../Src/: main.c app.c app_postprocess.c app_fuseprogramming.c stm32_lcd_ex.c stm32n6xx_it.c mcu_cache.c app_cam.c threadx_hal.c
